#include"ds1302.h"
//---DS1302写入和读取时分秒的地址命令---//
//---秒分时日月周年 最低位读写位;-------//
uchar code READ_RTC_ADDR[7] = {0x81, 0x83, 0x85, 0x87, 0x89, 0x8b, 0x8d}; 
uchar code WRITE_RTC_ADDR[7] = {0x80, 0x82, 0x84, 0x86, 0x88, 0x8a, 0x8c};

//---DS1302时钟初始化2026年11月5日星期3 11点59分05秒。---//
//---存储顺序是秒分时日月周年,存储格式是用BCD码---//
uchar code TIME[7] = {0x59, 0x59, 0x21, 0x04, 0x09, 0x04, 0x25};
unsigned char idata EasterEgg=0;
 /*******************************************************************************
* 函 数 名         : Ds1302WriteByte
* 函数功能		   : 向DS1302命令字节
* 输    入         : addr,dat
* 输    出         : 无
*******************************************************************************/

void DS1302WriteByte(unsigned char dat)
{ 
  unsigned char i;
  for (i=0;i<8;i++)
		{ 
			DSIO=dat & 0x01;	  //低位在前
			dat>>=1;
			SCLK = 1;_nop_();//数据在上升沿时，DS1302读取数据
			SCLK = 0;_nop_();
		}
}

/*******************************************************************************
* 函 数 名         : Ds1302ReadByte
* 函数功能		   : 向DS1302读字节
* 输    入         : addr,dat
* 输    出         : 无
*******************************************************************************/
 unsigned char DS1302ReadByte()
{ 
	unsigned char n;
	uchar dat1,dat;
	for(n=0; n<8; n++)//读取8位数据
	{
		dat1 = DSIO;//从最低位开始接收
		dat = (dat>>1) | (dat1<<7);
		SCLK = 1;_nop_();
		SCLK = 0;_nop_();//DS1302下降沿时，放置数据
	}
  return dat;
}

/*******************************************************************************
* 函 数 名         : Ds1302Write
* 函数功能		   : 向DS1302命令（地址+数据）
* 输    入         : addr,dat
* 输    出         : 无
*******************************************************************************/

void Ds1302Write(uchar addr, uchar dat)
{
	RST = 0;_nop_();
	SCLK = 0;_nop_();//先将SCLK置低电平。
	RST = 1;_nop_(); //然后将RST(CE)置高电平。
	DS1302WriteByte(addr);//写入8位命令
	DS1302WriteByte(dat);//	写入8位数据
  RST = 0;_nop_();//传送数据结束
}

/*******************************************************************************
* 函 数 名         : Ds1302Read
* 函数功能		   : 读取一个地址的数据
* 输    入         : addr
* 输    出         : dat
*******************************************************************************/

uchar Ds1302Read(uchar addr)
{
	uchar dat2;
	RST = 0;_nop_();
	SCLK = 0;_nop_();//先将SCLK置低电平。
	RST = 1;_nop_();//然后将RST(CE)置高电平。
	DS1302WriteByte(addr);_nop_();//写入8位地址命令
	DSIO = 1;_nop_();//MCU释放I/O
	dat2=DS1302ReadByte();
	RST = 0;_nop_();	//以下为DS1302复位的稳定时间,必须的。
	SCLK = 1;_nop_();
	DSIO = 0;_nop_();
	DSIO = 1;_nop_();
	return dat2;	///返回得到的时间/日期
}

/*******************************************************************************
* 函 数 名         : Ds1302Init
* 函数功能		   : 初始化DS1302.
* 输    入         : 无
* 输    出         : 无
*******************************************************************************/

unsigned char DataLoad()
{
	unsigned char m,n;
	m=Ds1302Read(0xC1);	 //根据Ds1302内31个字节RAM,首次上电时RAM中值为0xFF
	Ds1302Write(0x8E,0X00);		 //禁止写保护，就是关闭写保护功能
	if(m>0x06 || m==0)   // RAM 表示没掉电过
	{
		for (n=0; n<7; n++)//写入7个字节的时钟信号：分秒时日月周年
		{
			Ds1302Write(WRITE_RTC_ADDR[n],TIME[n]);	
		}
		Ds1302Write(0xC0,0x00);	//写入RAM中没掉电的标记，掉电时为0xFF
		//Ds1302Write(0x8E,0x80);		 //打开写保护功能
		return 0;
	}
	return m;
}