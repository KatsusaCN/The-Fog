# Keil uVision project The Final Art.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: The Final Art +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c 15W4Kxxxx.h oled.c oled.h pictures.c pictures.h Keyboard.c Keyboard.h ds1302.c ds1302.h Display.c Display.h
